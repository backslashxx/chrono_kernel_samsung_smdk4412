## drivers/lkm_template/Kconfig
```kconfig
menu "LKM TEMPLATE"

config LKM_TEMPLATE
	tristate "LKM TEMPLATE"
	default y
	help
	  simple LKM template communicating via sys_reboot

endmenu
```
